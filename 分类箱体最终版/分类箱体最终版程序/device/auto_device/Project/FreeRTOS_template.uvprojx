# Keil uVision project FreeRTOS_template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303RG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_template +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: ..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\GD32F30x_Firmware_Library\CMSIS;..\User\App;..\User\BSP;..\User\new_system;..\Third_Party\Modbus\app;..\Third_Party\Modbus\driver;..\Third_Party\Modbus;..\Third_Party\Modbus\functions;..\Third_Party\Modbus\include;..\Third_Party\Modbus\rtu;..\Third_Party\FreeRTOS\include;..\Third_Party\FreeRTOS;..\Third_Party\FreeRTOS\portable\RVDS\ARM_CM4F;..\User\DEVICE;..\User\DRIVER
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ../User/App/: main.c garbage.c menuconfig.h
    ../Third_Party/Modbus/app/: modbus_app.c modbus_app.h
  group HAL
    ../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group BSP
    ../User/BSP/: 74hc595.c 74hc595.h delay.c delay.h gd32f30x_it.c systick.c 74hc165.c 74hc165.h gd32f30x_it.h gd32f30x_libopt.h systick.h usart.c usart.h
  group modbus
    ../Third_Party/Modbus/: mb.c modbus_slave.c modbus_slave.h
    ../Third_Party/Modbus/driver/: port.h portevent.c portserial.c porttimer.c
    ../Third_Party/Modbus/functions/: mbfuncholding.c mbutils.c
    ../Third_Party/Modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../Third_Party/Modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group FreeRTOS
    ../Third_Party/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
    ../Third_Party/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../Third_Party/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Third_Party/FreeRTOS/: freertos_ex.c
  group startup
    ../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group drive
    ../User/DRIVER/: drv_ws2812b.c drv_ws2812b.h drv_user_led.c drv_user_led.h drv_sw.c drv_sw.h drv_key.c drv_key.h drv_human.c drv_human.h drv_ir.c drv_ir.h drv_motor.c drv_motor.h drv_adc.c drv_adc.h
  group device
    ../User/DEVICE/: dev_adc.c dev_adc.h dev_human.c dev_human.h dev_ir.c dev_ir.h dev_key.c dev_key.h dev_sw.c dev_sw.h dev_user_led.c dev_user_led.h dev_ws2812b.c dev_ws2812b.h dev_motor.c dev_motor.h
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0
