# Keil uVision project FreeRTOS_template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303RG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: ..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\GD32F30x_Firmware_Library\CMSIS;..\User\App;..\Third_Party\FreeRTOS\include;..\User\include;..\Third_Party\FreeRTOS\portable\RVDS\ARM_CM4F;..\User\BSP;..\Third_Party\Modbus\include;..\Third_Party\Modbus;..\Third_Party\Modbus\rtu;..\Third_Party\Modbus\driver;..\Third_Party\Modbus\app;..\User;..\User\device;..\User\driver;..\User\device_system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ../User/App/: gd32f30x_it.c main.c systick.c
  group HAL
    ../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group BSP
    ../User/BSP/: delay.c delay.h rs485.c rs485.h update.c update.h bootloader.c bootloader.h flash_drv.c flash_drv.h 74hc595.c 74hc595.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.2.0, Compiler:I/O:STDERR 1.2.0
